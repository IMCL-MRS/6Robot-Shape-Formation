# IAR project STM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../STM32F10x_StdPeriph_Driver/inc; ../CMSIS/Core/CM3; ../User/inc; ../FreeRTOSV7.2.0/include; ../FreeRTOSV7.2.0/portable/IAR/ARM_CM3; ../HalDriver/inc; ../MotionDriver6.1; ../Apps/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../STM32F10x_StdPeriph_Driver/inc; ../CMSIS/Core/CM3; ../User/inc; ../FreeRTOSV7.2.0/include; ../FreeRTOSV7.2.0/portable/IAR/ARM_CM3; ../MotionDriver6.1; ../Apps/inc
  OBJCOPY.OOCOutputFile: STM32.srec
  ILINK.IlinkOutputFile: STM32.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f100xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Apps/inc
    ../Apps/inc/: apps.h beep.h controlMotor.h function.h led.h readLightSensor.h readMPUSensor.h readSpeed.h RF.h robot.h uart.h
  group Apps/src
    ../Apps/src/: beep.c controlMotor.c function.c led.c readLightSensor.c readMPUSensor.c readSpeed.c RF.c robot.c uart.c
  group CMSIS
    ../CMSIS/Core/CM3/: core_cm3.c stm32f10x.h system_stm32f10x.c
  group CMSIS/startUp
    ../CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
  group FreeRTOSV7.2.0
    ../FreeRTOSV7.2.0/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOSV7.2.0/CLI
    ../FreeRTOSV7.2.0/CLI/: FreeRTOS_CLI.c
  group FreeRTOSV7.2.0/include
    ../FreeRTOSV7.2.0/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../FreeRTOSV7.2.0/CLI/: FreeRTOS_CLI.h
  group FreeRTOSV7.2.0/portable/IAR
    ../FreeRTOSV7.2.0/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOSV7.2.0/portable/MemMang
    ../FreeRTOSV7.2.0/portable/MemMang/: heap_2.c
  group HalDriver/inc
    ../HalDriver/inc/: halABDecoder.h halADC.h halBeep.h halDriver.h halI2C.h halLed.h halMCUWait.h halMotor.h halMPUInit.h halRCCInit.h halUsart.h
  group HalDriver/src
    ../HalDriver/src/: halABDecoder.c halADC.c halBeep.c halI2C.c halLed.c halMCUWait.c halMotor.c halMPUInit.c halRCCInit.c halUsart.c
  group MotionDriver6.1
    ../MotionDriver6.1/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group STM32F10x_StdPeriph_Driver/inc
    ../STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Driver/src
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User/inc
    ../User/inc/: AStar.h behaviors.h colAvoidance.h fc.h FreeRTOSConfig.h interruptMotorTask.h multiRobotVM.h neighbours.h snake.h stm32f10x_conf.h stm32f10x_it.h sysConfig.h vAccelatorTask.h vBCastInfoTask.h vDemoCtl.h vDemoTask.h vExample.h vInfoList.h vLocalizationTask.h vLocationTask.h vMagTask.h vMeldTask.h vMotorControlTask.h vTasks.h
  group User/src
    ../User/src/: AStar.c behaviors.c colAvoidance.c interruptMotorTask.c main.c multiRobotVM.c neighbours.c snake.c stm32f10x_it.c vAccelatorTask.c vBCastInfoTask.c vDemoFourTask.c vDemoOneTask.c vDemoThreeTask.c vDemoTwoTask.c vDistributedTask.c vExample.c vInfoList.c vLocalizationTask.c vLocationTask.c vMagTask.c vMeldTask.c vMotorControlTask.c vSnakeTask.c vStackCheck.c
